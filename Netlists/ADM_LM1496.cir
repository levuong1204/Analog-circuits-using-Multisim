** ADM_LM1496 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:16:20
*

*## Multisim Instrument XSC2 ##*

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -12

*## Multisim Component C6 ##*
cC6 1 0 2.2e-09

*## Multisim Component C5 ##*
cC5 10 vout 4.7e-09

*## Multisim Component R18 ##*
rR18 10 1 56000 vresR18
.model vresR18 r(  )

*## Multisim Component R17 ##*
rR17 vout1 10 56000 vresR17
.model vresR17 r(  )

*## Multisim Component U3 ##*
xU3 vout vout 1 U3_OPEN_VS- U3_OPEN_VS+ 741__OPAMP__1

*## Multisim Component D2 ##*
dD2 vo_am vout1 1N4149__DIODE__1

*## Multisim Component C4 ##*
* !!!BEGIN-INTERACT
*  : increment  ++++f4 ;
*  : tcapacitance  ++++f6 ;
*  0.0          constant mindval
*  100.0        constant maxdval
*  tcapacitance VARIABLE capacitance
*  50.0         VARIABLE setting
*  0            VARIABLE num_stored
*  0.0          VARIABLE setcapval
*  0.0          VARIABLE zeroadj
*  0.0          VARIABLE setfactor
*  0            VARIABLE flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*     *flag 0 = if
*        LOAD_FICL_VARIABLES
*        ==>_*num_stored
*        ==>_*num_stored
*        *num_stored 0 > if
*           ==>_*setting
*           ==>_*setcapval
*          *setcapval tcapacitance f./ ==>_*setfactor
*          *setcapval SET_INSTANCE Capacitor ::C C1  capacitance
*        endif
*      1 ==>_*flag
*      endif
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0001 0.999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor tcapacitance f.* capacitance GRADUAL_CHANGE_AT_RUN
*      *setfactor tcapacitance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value SET_INSTANCE Capacitor ::C C1  capacitance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
* !!!END-INTERACT
xC4 vout1 0 VariableCapacitorC4
.subckt VariableCapacitorC4 1 2
C1 1 2  50e-12
.ends

*## Multisim Component R16 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR16 0 6 6  PotentiometerR16
.subckt PotentiometerR16 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R15 ##*
rR15 vout1 6 10000 vresR15
.model vresR15 r(  )

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XSC3 ##*
XSC3 vm vc vo_am XSC3_OPEN_4 XSC3_OPEN_5 0 XSC3_OPEN_7 XXSC3_609099888

*## Multisim Component R14 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR14 16 VEE 17  PotentiometerR14
.subckt PotentiometerR14 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R13 ##*
rR13 vo_am 0 680 vresR13
.model vresR13 r(  )

*## Multisim Component Q1 ##*
qQ1 VCC 19 vo_am BC107BP__BJT_NPN__1

*## Multisim Component R12 ##*
rR12 13 14 1000 vresR12
.model vresR12 r(  )

*## Multisim Component R11 ##*
rR11 12 0 6800 vresR11
.model vresR11 r(  )

*## Multisim Component R10 ##*
rR10 11 0 51 vresR10
.model vresR10 r(  )

*## Multisim Component R9 ##*
rR9 17 11 750 vresR9
.model vresR9 r(  )

*## Multisim Component R8 ##*
rR8 16 9 750 vresR8
.model vresR8 r(  )

*## Multisim Component R7 ##*
rR7 9 0 51 vresR7
.model vresR7 r(  )

*## Multisim Component R5 ##*
rR5 VCC 8 3900 vresR5
.model vresR5 r(  )

*## Multisim Component R6 ##*
rR6 19 VCC 3900 vresR6
.model vresR6 r(  )

*## Multisim Component R4 ##*
rR4 5 VCC 1000 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 0 5 1000 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 4 5 51 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 2 11 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C3 ##*
cC3 5 0 1e-07

*## Multisim Component C2 ##*
cC2 vc 4 1e-07

*## Multisim Component C1 ##*
cC1 vm 2 1e-07

*## Multisim Instrument XFG2 ##*
XFG2 vm 0 XFG2_OPEN_1 XXFG2_609099888

*## Multisim Instrument XFG1 ##*
XFG1 XFG1_OPEN_3 0 vc XXFG1_609099888

*## Multisim Component U1 ##*
xU1 11 13 14 9 12 19 U1_OPEN_NC1 5 U1_OPEN_NC2 4 U1_OPEN_NC3 8 U1_OPEN_NC4 VEE LM1496N__LM1496N__1__1

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

.MODEL 1N4149__DIODE__1  D(Is=0.1p Rs=8 CJO=1p Tt=12n Bv=100 Ibv=0.1p )

.subckt XXSC3_609099888 1 2 3 4 5 6 0
vScopeTK_sync 6 0 dc 0 ac 1 0 pulse(0, 5, 0, 1.e-9, 1.e-9, 1e200, 2e200)
.ends

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33

.subckt XXFG1_609099888 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

*LM1496N 14 pins
*              +sig_in gain1 gain2 -sig_in bias out1 NC  +carr_in NC  -carr_in NC  out2 NC  V-
.subckt LM1496N__LM1496N__1__1     1      2     3      4     5    6   7      8     9      10    11   12  13  14
Q1 6 8 N001 0 CA3046
Q2 12 10 N001 0 CA3046
Q3 6 10 N002 0 CA3046
Q4 12 8 N002 0 CA3046
Q5 N001 4 3 0 CA3046
Q6 N002 1 2 0 CA3046
Q7 3 5 N003 0 CA3046
R1 N003 14 500
Q8 2 5 N004 0 CA3046
R2 N004 14 500
Q9 5 5 N005 0 CA3046
R3 N005 14 500
R101 7 9 1e12
R102 9 11 1e12
R103 11 13 1e12
R104 13 7 1e12
R105 13 0 1e12

.ends LM1496N

.model CA3046 NPN (IS=10e-15 BF=145.7E00 XTI=3E00 VAR=1.00E2 IKF=46.7E-03
+EG=1.110E00 VAF=1.00e02 ISE=114.286E-15 NE=1.48E00 XTB=0
+BR=0.1 ISC=10.005e-15 NC=2 IKR=10e-3 RC=10
+MJC=.333 VJC=.75 FC=5.00e-01 CJE=1.02e-12 MJE=.336 VJE=.75
+TR=10e-9 TF=277.01e-12 ITF=1.75 XTF=309.38 VTF=16.37)

  *******************

.subckt XXFG2_609099888 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
