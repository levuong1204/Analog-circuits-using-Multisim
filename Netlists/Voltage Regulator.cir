** Voltage Regulator **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 10:34:19
*

*## Multisim Instrument XMM1 ##*
XMM1 5 4 XXMM1_428781608

*## Multisim Component R2 ##*
rR2 5 4 2000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 2 5 2000 vresR1
.model vresR1 r(  )

*## Multisim Component D5 ##*
dD5 0 2 D1N4007GP__DIODE__1

*## Multisim Component D4 ##*
dD4 4 0 D1N4007GP__DIODE__1

*## Multisim Component D3 ##*
dD3 1 2 D1N4007GP__DIODE__1

*## Multisim Component D2 ##*
dD2 4 1 D1N4007GP__DIODE__1

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 {360*1.414213562} 60 0 0 0)

*## Multisim Component D1 ##*
dD1 4 5 1N4733A__ZENER__1

*## Multisim Component C1 ##*
cC1 2 0 0.0001

.subckt XXMM1_428781608 2 1
I_multi_meter 1 2 DC 0.000000e+00
R_multi_meter 2 1 1.000000e+09
.ends

.MODEL D1N4007GP__DIODE__1 D (
+   IS =  6.698e-07
+   RS =  0.04255
+   CJO =  1.949e-11
+   VJ =  0.3909
+   TT =  4.933e-06
+   M =  0.3577
+   BV =  1000
+   N =  2.412
+   EG =  1.11
+   XTI =  3
+   KF =  0
+   AF =  1
+   FC =  0.5
+   IBV =  0.005177
+   TNOM =  27
+ )

.MODEL 1N4733A__ZENER__1 D IS= 5.038e-012 RS= 0.001 CJO= 1e-012 VJ= 0.75
+                TT= 5e-009 M= 0.3333 BV= 5.111 IBV= 0.07542 N= 1
+                EG= 1.11 XTI= 3 KF= 0 AF= 1 FC= 0.5
+                TNOM= 27
