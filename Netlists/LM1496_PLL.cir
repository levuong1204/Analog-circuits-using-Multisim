** LM1496_PLL **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:13:48
*

*## Multisim Instrument XSA1 ##*

*## Multisim Component V1 ##*
vV1 2 0 dc 0
+   sffm(0 5 100000 2 5000)

*## Multisim Component A1 ##*
aA1 %vd (vout2 0) %vd (vout3 0) Gain_BlockA1
.MODEL Gain_BlockA1 gain(
+ gain=200
+ in_offset=0
+ out_offset=0)

*## Multisim Instrument XBP3 ##*

*## Multisim Instrument XBP2 ##*

*## Multisim Instrument XBP1 ##*

*## Multisim Instrument XSC4 ##*

*## Multisim Instrument XSC3 ##*

*## Multisim Component R7 ##*
rR7 4 0 10000 vresR7
.model vresR7 r(  )

*## Multisim Component R6 ##*
rR6 4 vout4 17800 vresR6
.model vresR6 r(  )

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -12

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Component U3 ##*
xU3 vout4 4 vout VEE VCC 741__OPAMP__1

*## Multisim Component R5 ##*
rR5 5 0 10000 vresR5
.model vresR5 r(  )

*## Multisim Component R4 ##*
rR4 5 vout 17800 vresR4
.model vresR4 r(  )

*## Multisim Component C4 ##*
cC4 1 0 1e-09

*## Multisim Component C2 ##*
cC2 3 vout 1e-09

*## Multisim Component U2 ##*
xU2 vout 5 1 VEE VCC 741__OPAMP__1

*## Multisim Component R3 ##*
rR3 3 1 15800 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 vout3 3 15800 vresR2
.model vresR2 r(  )

*## Multisim Instrument XSC2 ##*

*## Multisim Component C1 ##*
cC1 vout2 0 1e-06

*## Multisim Component R1 ##*
rR1 vout1 vout2 1000 vresR1
.model vresR1 r(  )

*## Multisim Instrument XSC1 ##*

*## Multisim Component A10 ##*
xA10 2 vout1 36 36 A10_OPEN_PDout PLL_VIRTA10
.subckt PLL_VIRTA10 PLLinraw Error PDinraw VCOout PDout
aPLLBuf PLLinraw PLLin PLLinBuff
aPDBuf PDinraw PDin PDinBuff
cC1 Error 0 {1/{2*3.14159*30000*3.6e3}}
rR1 PDout Error 3.6e3
aGlpf Error LPFout Buff1
aGpdout PDoutraw PDout Buff1
aGvco VCOraw VCOout VCOgain
aV2 %vd( LPFout 0 ) %vd( VCOraw 0 ) VCOmod
.MODEL VCOmod sine(
+ cntl_array = [-{12000/{1000*500}} 0 {12000/{1000*500}}]
+ freq_array = [0 12000 {2*12000}]
+ out_low = -1
+ out_high = 1)
xX1 PLLin PDoutraw PDin PhaseDetector_subckt
.subckt PhaseDetector_subckt PDin PDout PDref
aPD1 %vd ( PDin 0 ) %vd (  2  0 )   PDLim
aPD2 %vd ( PDref 0 ) %vd (  3  0 )   PDLim
aMLT [2 3] PDout PDMultiplier
.model PDMultiplier mult(
+ out_gain={0.25/0.23}
+ out_offset=0
+ in_offset=[0 0]
+ in_gain=[1 1])
.MODEL PDLim limit(
+ in_offset=0
+ gain=1
+ out_lower_limit=-1.5
+ out_upper_limit=1.5
+
+ )
.ENDS
.MODEL Buff1 gain(
+ gain=1.0
+ )
.MODEL PLLinBuff gain(
+ gain=1.0
+ in_offset=0)
.MODEL PDinBuff gain(
+ gain=1.0
+ in_offset=0)
.MODEL VCOgain gain(
+ gain=1
+ out_offset=0)
.ENDS

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS
