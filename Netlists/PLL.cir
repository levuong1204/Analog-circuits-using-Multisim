** PLL **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:14:06
*

*## Multisim Instrument XSC3 ##*
XSC3 Vfm Vlo Vo_mix Vfm_IF XSC3_OPEN_5 XSC3_OPEN_6 0 XXSC3_578777688

*## Multisim Instrument XSC4 ##*
XSC4 Vfm Vo1 vout Vm XSC4_OPEN_5 XSC4_OPEN_6 0 XXSC4_578777688

*## Multisim Instrument XSC5 ##*

*## Multisim Component U2 ##*
xU2 vout vout 7 VEE U2_OPEN_VS+ 741__OPAMP__1

*## Multisim Component C4 ##*
cC4 7 0 2e-09

*## Multisim Component C3 ##*
cC3 2 vout 4.7e-09

*## Multisim Component R4 ##*
rR4 2 7 56000 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 Vo1 2 56000 vresR3
.model vresR3 r(  )

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -12

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Instrument XSA1 ##*

*## Multisim Component V3 ##*
vV3 Vlo 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 0.1 110000 0 0 0)

*## Multisim Component C2 ##*
cC2 Vo_Raw 0 1.5e-07

*## Multisim Component R2 ##*
rR2 4 Vo_Raw 1000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 6 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component L1 ##*
lL1 5 6 0.01

*## Multisim Component C1 ##*
cC1 Vo_mix 5 1e-06

*## Multisim Instrument XSC2 ##*

*## Multisim Instrument XFG1 ##*
XFG1 XFG1_OPEN_3 0 Vm XXFG1_578777688

*## Multisim Component A4 ##*
aA4 %vd (Vo_Raw 0) %vd (Vo1 0) Gain_BlockA4
.MODEL Gain_BlockA4 gain(
+ gain=200
+ in_offset=0
+ out_offset=0)

*## Multisim Component A10 ##*
xA10 Vfm_IF 4 36 36 A10_OPEN_PDout PLL_VIRTA10
.subckt PLL_VIRTA10 PLLinraw Error PDinraw VCOout PDout
aPLLBuf PLLinraw PLLin PLLinBuff
aPDBuf PDinraw PDin PDinBuff
cC1 Error 0 {1/{2*3.14159*25000*3.6e3}}
rR1 PDout Error 3.6e3
aGlpf Error LPFout Buff1
aGpdout PDoutraw PDout Buff1
aGvco VCOraw VCOout VCOgain
aV2 %vd( LPFout 0 ) %vd( VCOraw 0 ) VCOmod
.MODEL VCOmod sine(
+ cntl_array = [-{11000/{1000*500}} 0 {11000/{1000*500}}]
+ freq_array = [0 11000 {2*11000}]
+ out_low = -1
+ out_high = 1)
xX1 PLLin PDoutraw PDin PhaseDetector_subckt
.subckt PhaseDetector_subckt PDin PDout PDref
aPD1 %vd ( PDin 0 ) %vd (  2  0 )   PDLim
aPD2 %vd ( PDref 0 ) %vd (  3  0 )   PDLim
aMLT [2 3] PDout PDMultiplier
.model PDMultiplier mult(
+ out_gain={0.25/0.23}
+ out_offset=0
+ in_offset=[0 0]
+ in_gain=[1 1])
.MODEL PDLim limit(
+ in_offset=0
+ gain=1
+ out_lower_limit=-1.5
+ out_upper_limit=1.5
+
+ )
.ENDS
.MODEL Buff1 gain(
+ gain=1.0
+ )
.MODEL PLLinBuff gain(
+ gain=1.0
+ in_offset=0)
.MODEL PDinBuff gain(
+ gain=1.0
+ in_offset=0)
.MODEL VCOgain gain(
+ gain=1
+ out_offset=0)
.ENDS

*## Multisim Component A3 ##*
aA3 %vd (6 0) %vd (Vfm_IF 0) Gain_BlockA3
.MODEL Gain_BlockA3 gain(
+ gain=24
+ in_offset=0
+ out_offset=0)

*## Multisim Instrument XFC1 ##*

*## Multisim Instrument XSC1 ##*

*## Multisim Component A2 ##*
aA2 [Vfm Vlo] Vo_mix MultiplierA2
.model MultiplierA2 mult(
+ out_gain=20
+ out_offset=0
+ in_offset=[0 0]
+ in_gain=[1 1])

*## Multisim Component A1 ##*
aA1 %vd (1 0) %vd (Vfm 0) Gain_BlockA1
.MODEL Gain_BlockA1 gain(
+ gain=20000
+ in_offset=0
+ out_offset=0)

*## Multisim Component V1 ##*
vV1 1 0 dc 0
+   sffm(0 5e-06 100000 2 1000)

.subckt XXSC4_578777688 1 2 3 4 5 6 0
vScopeTK_sync 6 0 dc 0 ac 1 0 pulse(0, 5, 0, 1.e-9, 1.e-9, 1e200, 2e200)
.ends

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

.subckt XXFG1_578777688 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

.subckt XXSC3_578777688 1 2 3 4 5 6 0
vScopeTK_sync 6 0 dc 0 ac 1 0 pulse(0, 5, 0, 1.e-9, 1.e-9, 1e200, 2e200)
.ends
