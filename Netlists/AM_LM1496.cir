** AMLM1496 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:16:09
*

*## Multisim Instrument XSC2 ##*
XSC2 vm vc vout_am XSC2_OPEN_4 XSC2_OPEN_5 XSC2_OPEN_6 0 XXSC2_605513120

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Instrument XSC5 ##*

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -8

*## Multisim Component R14 ##*
rR14 VCC 19 3900 vresR14
.model vresR14 r(  )

*## Multisim Component R5 ##*
rR5 vout_am 0 680 vresR5
.model vresR5 r(  )

*## Multisim Component C2 ##*
cC2 5 0 1e-07

*## Multisim Component C4 ##*
cC4 vc 2 1e-07

*## Multisim Component R13 ##*
rR13 5 VCC 1000 vresR13
.model vresR13 r(  )

*## Multisim Component R12 ##*
rR12 0 5 1000 vresR12
.model vresR12 r(  )

*## Multisim Component R2 ##*
rR2 2 5 51 vresR2
.model vresR2 r(  )

*## Multisim Component Q1 ##*
qQ1 VCC 19 vout_am BC107BP__BJT_NPN__1

*## Multisim Component R11 ##*
rR11 9 11 750 vresR11
.model vresR11 r(  )

*## Multisim Component R10 ##*
rR10 11 0 51 vresR10
.model vresR10 r(  )

*## Multisim Component R3 ##*
rR3 12 0 51 vresR3
.model vresR3 r(  )

*## Multisim Component R9 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR9 8 VEE 9  PotentiometerR9
.subckt PotentiometerR9 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R8 ##*
rR8 7 11 1000 vresR8
.model vresR8 r(  )

*## Multisim Component C1 ##*
cC1 vm 7 1e-07

*## Multisim Instrument XFG2 ##*
XFG2 XFG2_OPEN_3 0 vm XXFG2_605513120

*## Multisim Instrument XFG1 ##*
XFG1 XFG1_OPEN_3 0 vc XXFG1_605513120

*## Multisim Component R7 ##*
rR7 4 0 6800 vresR7
.model vresR7 r(  )

*## Multisim Component R6 ##*
rR6 1 3 1000 vresR6
.model vresR6 r(  )

*## Multisim Component R4 ##*
rR4 VCC 6 3900 vresR4
.model vresR4 r(  )

*## Multisim Component R1 ##*
rR1 8 12 750 vresR1
.model vresR1 r(  )

*## Multisim Component U1 ##*
xU1 11 1 3 12 4 19 U1_OPEN_NC1 5 U1_OPEN_NC2 2 U1_OPEN_NC3 6 U1_OPEN_NC4 VEE LM1496N__LM1496N__1__1

.subckt XXSC2_605513120 1 2 3 4 5 6 0
vScopeTK_sync 6 0 dc 0 ac 1 0 pulse(0, 5, 0, 1.e-9, 1.e-9, 1e200, 2e200)
.ends

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33

.subckt XXFG2_605513120 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

.subckt XXFG1_605513120 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

*LM1496N 14 pins
*              +sig_in gain1 gain2 -sig_in bias out1 NC  +carr_in NC  -carr_in NC  out2 NC  V-
.subckt LM1496N__LM1496N__1__1     1      2     3      4     5    6   7      8     9      10    11   12  13  14
Q1 6 8 N001 0 CA3046
Q2 12 10 N001 0 CA3046
Q3 6 10 N002 0 CA3046
Q4 12 8 N002 0 CA3046
Q5 N001 4 3 0 CA3046
Q6 N002 1 2 0 CA3046
Q7 3 5 N003 0 CA3046
R1 N003 14 500
Q8 2 5 N004 0 CA3046
R2 N004 14 500
Q9 5 5 N005 0 CA3046
R3 N005 14 500
R101 7 9 1e12
R102 9 11 1e12
R103 11 13 1e12
R104 13 7 1e12
R105 13 0 1e12

.ends LM1496N

.model CA3046 NPN (IS=10e-15 BF=145.7E00 XTI=3E00 VAR=1.00E2 IKF=46.7E-03
+EG=1.110E00 VAF=1.00e02 ISE=114.286E-15 NE=1.48E00 XTB=0
+BR=0.1 ISC=10.005e-15 NC=2 IKR=10e-3 RC=10
+MJC=.333 VJC=.75 FC=5.00e-01 CJE=1.02e-12 MJE=.336 VJE=.75
+TR=10e-9 TF=277.01e-12 ITF=1.75 XTF=309.38 VTF=16.37)

  *******************
