** CE Amplifier **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:15:08
*

*## Multisim Component R4 ##*
rR4 3 0 10000 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 VCC 3 47000 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 1 0 470 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 VCC 2 4700 vresR1
.model vresR1 r(  )

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 10

*## Multisim Component Q1 ##*
qQ1 2 3 1 BC547A__BJT_NPN__1

*## Multisim Instrument XSC1 ##*

*## Multisim Component V1 ##*
vV1 5 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 0.01 1000 0 0 0)

*## Multisim Component R5 ##*
rR5 4 0 47000 vresR5
.model vresR5 r(  )

*## Multisim Component C3 ##*
cC3 1 0 1e-05

*## Multisim Component C2 ##*
cC2 2 4 1e-05

*## Multisim Component C1 ##*
cC1 5 3 1e-05

.MODEL BC547A__BJT_NPN__1 npn
+IS=1.89314e-14 BF=1536.18 NF=0.942746 VAF=16.0274
+IKF=0.095245 ISE=4.13018e-14 NE=1.2599 BR=0.1
+NR=1.13089 VAR=1.05111 IKR=0.622681 ISC=1.79252e-14
+NC=2.7038 RB=3.11982 IRB=0.1 RBM=0.1
+RE=0.0001 RC=0.001 XTB=0.1 XTI=1
+EG=1.05 CJE=7.68434e-12 VJE=0.4 MJE=0.349069
+TF=5.80579e-10 XTF=4.00934 VTF=28.4173 ITF=0.176065
+CJC=3.9003e-12 VJC=0.821072 MJC=0.329281 XCJC=0.8
+FC=0.8 CJS=0 VJS=0.75 MJS=0.5
+TR=1e-07 PTF=0 KF=0 AF=1
