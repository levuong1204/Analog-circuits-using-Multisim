** ADC Converter **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:16:37
*

*## Multisim Instrument XMM2 ##*
XMM2 5 0 XXMM2_609144944

*## Multisim Instrument XMM1 ##*
XMM1 1 2 XXMM1_609144944

*## Multisim Instrument XSC1 ##*

*## Multisim Component C1 ##*
cC1 5 0 0.001

*## Multisim Component D1 ##*
xD1 3 4 5 0 G3SBA60/VSH__FWB__1

*## Multisim Component T1 ##*
xT1 1 2 3 4 Tran_T1
.subckt Tran_T1 p1pos p1neg s1pos s1neg
***Primary coil 1

G1 p1pos p1neg value={-1/10*(1*I(Es1))}

***Secondary coil 1

Es1 s1pos s1neg value={V(p1pos,p1neg)*1/10}

.ends

*## Multisim Component V1 ##*
vV1 1 2 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 135 1000 0 0 0)

.subckt XXMM2_609144944 2 1
I_multi_meter 1 2 DC 0.000000e+00
R_multi_meter 2 1 1.000000e+09
.ends

.subckt XXMM1_609144944 2 1
I_multi_meter 1 2 DC 0.000000e+00
R_multi_meter 2 1 1.000000e+09
.ends

****************************************
* (c)1999 Thomatronik GmbH             *
*   info@thomatronik.de                *
*                                      *
* Author: Arpad Buermen                *
*   Arpad.Burmen@ieee.org              *
****************************************
* Nodes 1 and 2: AC input
* Nodes 3 and 4: +/- DC output
.SUBCKT G3SBA60/VSH__FWB__1 1 2 3 4
D1 1 3 LEGD
D2 2 3 LEGD
D3 4 1 LEGD
D4 4 2 LEGD
.MODEL LEGD D (
+   N=1.796
+  IS=1.22106E-008
+  RS=0.0138402
+  EG=1.11
+ XTI=3
+ CJO=1.07747E-010
+  VJ=0.21
+   M=0.304622
+  FC=0.5
+  TT=2.88539E-006
+  BV=600
+ IBV=0.0004
+  KF=0
+  AF=1 )
.ENDS
