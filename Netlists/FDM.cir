** FDM2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:14:49
*

*## Multisim Component S6 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS6 vo_DSB2_filter 81 vo_DSB2  SwitchS6 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS6 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component S5 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS5 vc2 80 vm2  SwitchS5 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS5 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component S1 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS1 81 59 80  SwitchS1 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS1 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Instrument XSA2 ##*

*## Multisim Instrument XSC5 ##*

*## Multisim Component S4 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS4 vm2_raw 79 vo_DSB2_filter  SwitchS4 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS4 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component S3 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS3 vout2 78 vm2  SwitchS3 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS3 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component S2 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS2 79 77 78  SwitchS2 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS2 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Instrument XSA1 ##*

*## Multisim Instrument XSC4 ##*

*## Multisim Component C46 ##*
cC46 0 75 1e-08

*## Multisim Component R76 ##*
rR76 75 74 6800 vresR76
.model vresR76 r(  )

*## Multisim Component C45 ##*
cC45 0 73 1.5e-09

*## Multisim Component C44 ##*
cC44 74 vout2 2.2e-08

*## Multisim Component R75 ##*
rR75 76 75 6800 vresR75
.model vresR75 r(  )

*## Multisim Component R74 ##*
rR74 74 73 6800 vresR74
.model vresR74 r(  )

*## Multisim Component U21 ##*
xU21 vout2 vout2 73 VEE VCC 741__OPAMP__1

*## Multisim Component C43 ##*
cC43 72 vm2_raw 1e-07

*## Multisim Component R73 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR73 70 VEE 71  PotentiometerR73
.subckt PotentiometerR73 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R72 ##*
rR72 72 0 680 vresR72
.model vresR72 r(  )

*## Multisim Component Q1 ##*
qQ1 VCC 65 72 BC107BP__BJT_NPN__1

*## Multisim Component R71 ##*
rR71 61 62 1000 vresR71
.model vresR71 r(  )

*## Multisim Component R70 ##*
rR70 64 0 6800 vresR70
.model vresR70 r(  )

*## Multisim Component R69 ##*
rR69 60 0 51 vresR69
.model vresR69 r(  )

*## Multisim Component R68 ##*
rR68 71 60 750 vresR68
.model vresR68 r(  )

*## Multisim Component R67 ##*
rR67 70 63 750 vresR67
.model vresR67 r(  )

*## Multisim Component R66 ##*
rR66 63 0 51 vresR66
.model vresR66 r(  )

*## Multisim Component R65 ##*
rR65 VCC 68 3900 vresR65
.model vresR65 r(  )

*## Multisim Component R64 ##*
rR64 65 VCC 3900 vresR64
.model vresR64 r(  )

*## Multisim Component R63 ##*
rR63 66 VCC 1000 vresR63
.model vresR63 r(  )

*## Multisim Component R62 ##*
rR62 0 66 1000 vresR62
.model vresR62 r(  )

*## Multisim Component R61 ##*
rR61 67 66 51 vresR61
.model vresR61 r(  )

*## Multisim Component R60 ##*
rR60 69 60 1000 vresR60
.model vresR60 r(  )

*## Multisim Component C42 ##*
cC42 66 0 1e-07

*## Multisim Component C41 ##*
cC41 vc2_1 67 1e-07

*## Multisim Component C40 ##*
cC40 vo_DSB2_filter 69 1e-07

*## Multisim Instrument XFG16 ##*
XFG16 XFG16_OPEN_3 0 vc2_1 XXFG16_432416080

*## Multisim Component U20 ##*
xU20 60 61 62 63 64 65 U20_OPEN_NC1 66 U20_OPEN_NC2 67 U20_OPEN_NC3 68 U20_OPEN_NC4 VEE LM1496N__LM1496N__1__1

*## Multisim Component A1 ##*
xA1 vm2_raw 76 Gain2pin_A1 PARAMS: gain=20
.subckt Gain2pin_A1 in out  PARAMS: gain=1
E1 out 0 value = { gain * v(in) }
.ends

*## Multisim Component U19 ##*
xU19 56 56 57 VEE VCC 741__OPAMP__1

*## Multisim Component R59 ##*
rR59 56 58 9100 vresR59
.model vresR59 r(  )

*## Multisim Component C39 ##*
cC39 vo_DSB2 58 1e-09

*## Multisim Component R58 ##*
rR58 57 0 9100 vresR58
.model vresR58 r(  )

*## Multisim Component C38 ##*
cC38 58 57 1e-09

*## Multisim Component C37 ##*
cC37 0 54 1e-10

*## Multisim Component C36 ##*
cC36 55 vo_DSB2_filter 1e-10

*## Multisim Component R57 ##*
rR57 56 55 27000 vresR57
.model vresR57 r(  )

*## Multisim Component R56 ##*
rR56 55 54 27000 vresR56
.model vresR56 r(  )

*## Multisim Component U18 ##*
xU18 vo_DSB2_filter vo_DSB2_filter 54 VEE VCC 741__OPAMP__1

*## Multisim Component C35 ##*
cC35 53 39 1e-07

*## Multisim Component R55 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR55 51 VEE 52  PotentiometerR55
.subckt PotentiometerR55 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R54 ##*
rR54 53 0 680 vresR54
.model vresR54 r(  )

*## Multisim Component Q2 ##*
qQ2 VCC 46 53 BC107BP__BJT_NPN__1

*## Multisim Component R53 ##*
rR53 42 43 1000 vresR53
.model vresR53 r(  )

*## Multisim Component R52 ##*
rR52 45 0 6800 vresR52
.model vresR52 r(  )

*## Multisim Component R51 ##*
rR51 40 0 51 vresR51
.model vresR51 r(  )

*## Multisim Component R50 ##*
rR50 52 40 750 vresR50
.model vresR50 r(  )

*## Multisim Component R49 ##*
rR49 51 44 750 vresR49
.model vresR49 r(  )

*## Multisim Component R48 ##*
rR48 44 0 51 vresR48
.model vresR48 r(  )

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Component R47 ##*
rR47 VCC 49 3900 vresR47
.model vresR47 r(  )

*## Multisim Component R46 ##*
rR46 46 VCC 3900 vresR46
.model vresR46 r(  )

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -12

*## Multisim Component R45 ##*
rR45 47 VCC 1000 vresR45
.model vresR45 r(  )

*## Multisim Component R44 ##*
rR44 0 47 1000 vresR44
.model vresR44 r(  )

*## Multisim Component R43 ##*
rR43 48 47 51 vresR43
.model vresR43 r(  )

*## Multisim Component R42 ##*
rR42 50 40 1000 vresR42
.model vresR42 r(  )

*## Multisim Component C34 ##*
cC34 47 0 1e-07

*## Multisim Component C33 ##*
cC33 vc2 48 1e-07

*## Multisim Component C32 ##*
cC32 vm2 50 1e-07

*## Multisim Instrument XFG15 ##*
XFG15 XFG15_OPEN_3 0 vm2 XXFG15_432416080

*## Multisim Instrument XFG14 ##*
XFG14 XFG14_OPEN_3 0 vc2 XXFG14_432416080

*## Multisim Component U17 ##*
xU17 40 42 43 44 45 46 U17_OPEN_NC1 47 U17_OPEN_NC2 48 U17_OPEN_NC3 49 U17_OPEN_NC4 VEE LM1496N__LM1496N__1__1

*## Multisim Component A2 ##*
xA2 39 vo_DSB2 Gain2pin_A2 PARAMS: gain=20
.subckt Gain2pin_A2 in out  PARAMS: gain=1
E1 out 0 value = { gain * v(in) }
.ends

.subckt XXFG16_432416080 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33

.subckt XXFG14_432416080 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

*LM1496N 14 pins
*              +sig_in gain1 gain2 -sig_in bias out1 NC  +carr_in NC  -carr_in NC  out2 NC  V-
.subckt LM1496N__LM1496N__1__1     1      2     3      4     5    6   7      8     9      10    11   12  13  14
Q1 6 8 N001 0 CA3046
Q2 12 10 N001 0 CA3046
Q3 6 10 N002 0 CA3046
Q4 12 8 N002 0 CA3046
Q5 N001 4 3 0 CA3046
Q6 N002 1 2 0 CA3046
Q7 3 5 N003 0 CA3046
R1 N003 14 500
Q8 2 5 N004 0 CA3046
R2 N004 14 500
Q9 5 5 N005 0 CA3046
R3 N005 14 500
R101 7 9 1e12
R102 9 11 1e12
R103 11 13 1e12
R104 13 7 1e12
R105 13 0 1e12

.ends LM1496N

.model CA3046 NPN (IS=10e-15 BF=145.7E00 XTI=3E00 VAR=1.00E2 IKF=46.7E-03
+EG=1.110E00 VAF=1.00e02 ISE=114.286E-15 NE=1.48E00 XTB=0
+BR=0.1 ISC=10.005e-15 NC=2 IKR=10e-3 RC=10
+MJC=.333 VJC=.75 FC=5.00e-01 CJE=1.02e-12 MJE=.336 VJE=.75
+TR=10e-9 TF=277.01e-12 ITF=1.75 XTF=309.38 VTF=16.37)

  *******************

.subckt XXFG15_432416080 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
