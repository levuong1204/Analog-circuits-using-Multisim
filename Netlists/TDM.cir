** TDM_LV **
*
* NI Multisim to SPICE Netlist Export
* Generated by: levuo
* Mon, Jun 24, 2024 14:12:35
*

*## Multisim Instrument XSC4 ##*

*## Multisim Instrument XSC1 ##*

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -12

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Component U10 ##*
xU10 vin_4 vin_4 26 VEE VCC 741__OPAMP__1

*## Multisim Component C12 ##*
cC12 23 vout_4 2.2e-08

*## Multisim Component C11 ##*
cC11 21 0 1.5e-09

*## Multisim Component C10 ##*
cC10 0 22 1e-08

*## Multisim Component R12 ##*
rR12 23 21 6800 vresR12
.model vresR12 r(  )

*## Multisim Component R11 ##*
rR11 22 23 6800 vresR11
.model vresR11 r(  )

*## Multisim Component R10 ##*
rR10 vin_4 22 6800 vresR10
.model vresR10 r(  )

*## Multisim Component U9 ##*
xU9 vout_4 vout_4 21 VEE VCC 741__OPAMP__1

*## Multisim Component U8 ##*
xU8 vin_3 vin_3 25 VEE VCC 741__OPAMP__1

*## Multisim Component C9 ##*
cC9 20 vout_3 2.2e-08

*## Multisim Component C8 ##*
cC8 18 0 1.5e-09

*## Multisim Component C7 ##*
cC7 0 19 1e-08

*## Multisim Component R9 ##*
rR9 20 18 6800 vresR9
.model vresR9 r(  )

*## Multisim Component R8 ##*
rR8 19 20 6800 vresR8
.model vresR8 r(  )

*## Multisim Component R7 ##*
rR7 vin_3 19 6800 vresR7
.model vresR7 r(  )

*## Multisim Component U7 ##*
xU7 vout_3 vout_3 18 VEE VCC 741__OPAMP__1

*## Multisim Component U6 ##*
xU6 vin_2 vin_2 24 VEE VCC 741__OPAMP__1

*## Multisim Component C6 ##*
cC6 17 vout_2 2.2e-08

*## Multisim Component C5 ##*
cC5 15 0 1.5e-09

*## Multisim Component C4 ##*
cC4 0 16 1e-08

*## Multisim Component R6 ##*
rR6 17 15 6800 vresR6
.model vresR6 r(  )

*## Multisim Component R5 ##*
rR5 16 17 6800 vresR5
.model vresR5 r(  )

*## Multisim Component R4 ##*
rR4 vin_2 16 6800 vresR4
.model vresR4 r(  )

*## Multisim Component U5 ##*
xU5 vout_2 vout_2 15 VEE VCC 741__OPAMP__1

*## Multisim Component U4 ##*
xU4 vin_1 vin_1 5 VEE VCC 741__OPAMP__1

*## Multisim Component C3 ##*
cC3 14 vout_1 2.2e-08

*## Multisim Component C2 ##*
cC2 12 0 1.5e-09

*## Multisim Component C1 ##*
cC1 0 13 1e-08

*## Multisim Component R3 ##*
rR3 14 12 6800 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 13 14 6800 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 vin_1 13 6800 vresR1
.model vresR1 r(  )

*## Multisim Component U2 ##*
xU2 vout_1 vout_1 12 VEE VCC 741__OPAMP__1

*## Multisim Component V6 ##*
xV6 7 0 NIBATV6
.subckt NIBATV6 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*5}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Component V5 ##*
xV5 0 9 NIBATV5
.subckt NIBATV5 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*12}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Component V4 ##*
xV4 8 0 NIBATV4
.subckt NIBATV4 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*12}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Component S4 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS4 CH2 10 CH1  SwitchS4 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS4 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component S3 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS3 CH4 11 CH3  SwitchS3 Params: Ron=0.0001 Roff=100000000

.subckt SwitchS3 1 2 3 Params: Ron=1e-8 Roff=1e30
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
W1 2 3 V1 NO_contact
.MODEL NO_contact csw (IT=0.05 IH=0.025 RON={Ron} ROFF={Roff})
.MODEL NC_contact csw (IT=0.05 IH=0.025 RON={Roff} ROFF={Ron})
.ENDS

*## Multisim Component V3 ##*
xV3 4 0 NIBATV3
.subckt NIBATV3 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*12}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Component V1 ##*
xV1 0 6 NIBATV1
.subckt NIBATV1 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*12}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Component V2 ##*
xV2 3 0 NIBATV2
.subckt NIBATV2 2 1
*********************************************************************************
*NOTE: Due to initial charge on Cchrg (Capacitor), Default Instrument
*           Settings must be set to User Defined in order for this part to
*           simulate correctly.
*********************************************************************************
Bset 1 10 v={v(31)*5}
Rint 10 11 0.1
Vsen 2 11 DC 0
Cf 0 20 1e-6
Rf 20 21 1e6
Bf 21 0 v={i(Vsen)/300}
Cchrg 0 30 {3600*300} IC=1
Blost 30 31 v=v(20)
Bvsen 31 0 i={i(Vsen)}
.ends

*## Multisim Instrument XBP1 ##*

*## Multisim Instrument XFG5 ##*
XFG5 XFG5_OPEN_3 0 CH1 XXFG5_420821240

*## Multisim Instrument XFG4 ##*
XFG4 XFG4_OPEN_3 0 CH2 XXFG4_420821240

*## Multisim Instrument XFG3 ##*
XFG3 XFG3_OPEN_3 0 CH3 XXFG3_420821240

*## Multisim Instrument XFG2 ##*
XFG2 XFG2_OPEN_3 0 CH4 XXFG2_420821240

*## Multisim Instrument XSC3 ##*

*## Multisim Instrument XSC2 ##*

*## Multisim Component S2 ##*
xS2 5 24 25 26 S2_OPEN_S1B S2_OPEN_S2B S2_OPEN_S3B S2_OPEN_S4B CK2 CK1 7 TDM S2_OPEN_DB 8 0 9 ADG409__ANALOG_SWITCH__1

*## Multisim Component S1 ##*
xS1 CH1 CH2 CH3 CH4 S1_OPEN_S1B S1_OPEN_S2B S1_OPEN_S3B S1_OPEN_S4B CK2 CK1 3 TDM S1_OPEN_DB 4 0 6 ADG409__ANALOG_SWITCH__1

*## Multisim Component U1 ##*
aU1_A  [2
+      dU1.SD1
+      dU1.CD1
+      1]
+     [dU1.O1
+      2] 4013B_5__CMOS_5V__1

xU1_A.O1 dU1.O1 CK2 VCC VSS CMOS_DRV__NON__1

xU1_A.CD1 0 dU1.CD1 VCC VSS CMOS_RCV__NON__1

xU1_A.SD1 0 dU1.SD1 VCC VSS CMOS_RCV__NON__1

*## Multisim Component U1 ##*
aU1_B [1
+      dU1.SD2
+      dU1.CD2
+      dU1.CP2]
+     [dU1.O2
+      1] 4013B_5__CMOS_5V__1

xU1_B.O2 dU1.O2 CK1 VCC VSS CMOS_DRV__NON__1

xU1_B.CD2 0 dU1.CD2 VCC VSS CMOS_RCV__NON__1

xU1_B.CP2 CK dU1.CP2 VCC VSS CMOS_RCV__NON__1

xU1_B.SD2 0 dU1.SD2 VCC VSS CMOS_RCV__NON__1

*## Multisim Instrument XFG1 ##*
XFG1 XFG1_OPEN_3 0 CK XXFG1_420821240

.SUBCKT 741__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 15 VEE= -15 CC= 3e-011 A= 200000 RI= 2e+006
* RO= 75 VOS= 0.001 IOS= 2e-008 IBS= 8e-008
* VSW+= 14 VSW-= -14 CMMR= 90
* ISC= 0.025 SR= 0.5 Fu= 1e+006 Pm= 6.09112e-007
    VC 5 15 DC 1.68573V
    VE 12 4 DC 1.68573V
    IEE 10 4 DC 1.516e-005A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 5305.16ohm
    Rc2  5  7 5305.16ohm
    Re1  9 10 1839.19ohm
    Re2  8 10 1839.19ohm
    Ro1  1 14 37.5ohm
    Ro2 14  0 37.5ohm
    Ree 10  0 1.31926e+007ohm
    Rcc  0 13 2.20906e-005ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.000188496
    GC   0 13  1  0 45268.1
    GB  14  0 11  0 282.942
    GCM  0 11 10  0 5.96075e-009
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=7.53769e-014A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=83.3333 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.30948e-016A BF=107.143 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

* ADG409 SPICE Macro-model                10/95, Rev. A
*                                           JOM / ADSC
*
* Revision History: NONE
*
*	NOTE: This model was setup with typical leakage currents
*		at +25C for ADG409
*
* Copyright 1995 by Analog Devices, Inc.
*
* Refer to "README.DOC" file for License Statement.  Use of this
* model indicates your acceptance with the terms and provisions
* in the License Statement.
*
* Node assignments
* 4 - S1A, 5 - S2A, 6 - S3A, 7 - S4A, 13 - S1B, 12 - S2B, 11 - S3B
* 10 - S4B, 16 - A1, 1 - A0, 2 - EN
* 8 - DA, 9 - DB, 14 - VDD, 15 - GND, 3 - VSS
*
.SUBCKT ADG409__ANALOG_SWITCH__1  4 5 6 7 13 12 11 10 16 1 2 8 9 14 15 3
*
* DEMUX SWITCHES (S1-8 ---> D)
*
*     First Section is for control line A0
*

E_A0_2	  200 15   1 15    1
E_A0_1     30 40 201 40   -1
R_A0_1    200 201         1000
C_A0_X2   201 15          100E-12

V_AX_1     40  15          1.6

S_A0_4B     10 34 201 15   Sdemux
S_A0_3B     11 34 30  15   Sdemux
S_A0_2B     12 33 201 15   Sdemux
S_A0_1B     13 33 30  15   Sdemux

S_A0_4A      7 32 201 15   Sdemux
S_A0_3A      6 32 30  15   Sdemux
S_A0_2A      5 31 201 15   Sdemux
S_A0_1A      4 31 30  15   Sdemux

C_A0_X1     1 15          4E-12
C_A0_DA      1 43          2E-12
C_A0_DB      1 42          2E-12

*          Input capacitances

C_A0_1A      4  15         8E-12
C_A0_2A      5  15         8E-12
C_A0_3A      6  15	   8E-12
C_A0_4A      7  15         8E-12

C_A0_1B     13  15         8E-12
C_A0_2B     12  15         8E-12
C_A0_3B     11  15         8E-12
C_A0_4B     10  15         8E-12

C_DA_1       8  15         80E-12
C_DB_2       9  15         80E-12

*
*	Leakage Current (SX and D ON only)
*

R_ON_SA1     4 500    1.5E12
R_ON_SA2    5 500    1.5E12
R_ON_SA3     6 500    1.5E12
R_ON_SA4     7 500    1.5E12

R_ON_SB1    13 500    1.5E12
R_ON_SB2    12 500    1.5E12
R_ON_SB3    11 500    1.5E12
R_ON_SB4    10 500    1.5E12

SLEAK_ON_DA  8 500    8 500  SLEAK
ILEAK_ON_DA  8 500    10E-12

SLEAK_ON_DB  9 500    9 500  SLEAK
ILEAK_ON_DB  9 500    10E-12
*
*	Leakage Current (SX OFF only)
*
*	Leakage Current (D OFF only)
*

S_OFF_DA     8  58 80 15	  Sdemux
R_OFF_DA    58  15         1E12
G_OFF_DA     8  15 58 15   0.75E-12

S_OFF_DB     9  59 80 15	  Sdemux
R_OFF_DB    59  15         1E12
G_OFF_DB     9  15 59 15   0.75E-12
*C_OFF_D     59  15                0E-12
*
*     Second Section is for control line A1
*

E_A1_2	  170 15 16  15    1
E_A1_1     41 40 171 40   -1
R_A1_1    170 171         1000
C_A1_X2   171 15          100E-12

S_A1_2B     34 42 171 15     Sdemux
S_A1_1B     33 42 41  15     Sdemux

S_A1_2A     32 43 171 15    Sdemux
S_A1_1A     31 43 41  15    Sdemux

C_A1_X     16 15           4E-12
C_A1_DA    16 43           2E-12
C_A1_DB    16 42           2E-12

*
*     Main Series Switch combination - A
*
*

V_1_A     419   15  15
V_1_B     420   15  -15
V_1_C     421   14  -1        ;sets pos main offset
V_1_D     422    3  2		;sets neg main offset
R_1_C      43   0         1E13
S_1_A     425  43 420  73 SNCM
R_1_A     412 425         29		;sets neg at max d
S_1_B     426  43 419  73 SPCM
R_1_B      73 426         50            ;sets pos at max d
S_1_C      73 412 611  15 SMAINP
S_1_D     412 411  15 612 SMAINN
E_1_E     611  15         VALUE = {(10*V(73,500))/(V(421,500)+0.005)}
E_1_F     612  15         VALUE = {(10*V(73,500))/(V(500,422)+0.005)}
S_1_G     411  43  99   3 SBASE
*
*	Main Series Switch Combination -B
*
V_1_AB     519   15  15
V_1_BB     520   15  -15
V_1_CB     521   14  -1        ;sets pos main offset
V_1_DB     522    3  2		;sets neg main offset
R_1_CB      42   0         1E13
S_1_AB     525  42 520  83 SNCM
R_1_AB     512 525         29		;sets neg at max d
S_1_BB     526  42 519  83 SPCM
R_1_BB      83 526         50            ;sets pos at max d
S_1_CB      83 512 711  15 SMAINP
S_1_DB     512 511  15 712 SMAINN
E_1_EB     711  15         VALUE = {(10*V(73,500))/(V(521,500)+0.005)}
E_1_FB     712  15         VALUE = {(10*V(73,500))/(V(500,522)+0.005)}
S_1_GB     511  42  99   3 SBASE
*
*	Voltage Clamp
*

D_1_POSA     43  14          DClamp  .001
G_1_POSA     43  14  43  14  -1E-12
D_2_NEGA      3  43          DClamp  .001
G_2_NEGA      3  43   3  43  1E-12

D_1_POSB     42  14          DClamp  .001
G_1_POSB     42  14  42  14  -1E-12
D_2_NEGB      3  42          DClamp  .001
G_2_NEGB      3  42   3  42  1E-12
*
*     Enable Switch section
*

S_EN_1B    83  9  2  15    Sdemux
S_EN_1A    73  8  2  15    Sdemux
C_EN_1A     2  8           4.2E-12  ; SETS CHARGE INJECTION
C_EN_1B     2  9           4.2E-12

*     Invert Enable Switch section

E_EN0_1     80  15 2 82    -2
V_EN0_1	    82  15          2.5

*
*     Power Supply Current Correction
*

I_PS_1     14  15           80E-6
I_PS_2     15   3           0.0001E-6
E_PS_1     99  15  14  15   1
E_PS_2    500   3  14   3   .5

*
*	Crosstalk
*

RXT_1A      4 52           1E13
RXT_2A      5 52           1E13
RXT_3A      6 52           1E13
RXT_4A      7 52           1E13

RXT_1B     13 52           1E13
RXT_2B     12 52           1E13
RXT_3B     11 52           1E13
RXT_4B     10 52           1E13

CXT_1A      4 52           1E-12
CXT_2A      5 52           1E-12
CXT_3A      6 52           1E-12
CXT_4A      7 52           1E-12

CXT_1B     13 52           1E-12
CXT_2B     12 52           1E-12
CXT_3B     11 52           1E-12
CXT_4B     10 52           1E-12
*
*	OFF Isolation
*
COI_1AX      4  8           1E-13
COI_2AX      5  8           1E-13
COI_3AX      6  8           1E-13
COI_4AX      7  8           1E-13

COI_1BX     13  9          1E-13
COI_2BX     12  9           1E-13
COI_3BX     11  9           1E-13
COI_4BX     10  9           1E-13

ROI_1A        4 1901         1.6E9
COI_1A    1901    8         10E-12
ROI_2A        5 1902         1.6E9
COI_2A    1902    8         10E-12
ROI_3A        6 1903         1.6E9
COI_3A    1903    8         10E-12
ROI_4A        7 1904         1.6E9
COI_4A    1904    8         10E-12

ROI_1B       13 1905         1.6E9
COI_1B    1905    9         10E-12
ROI_2B       12 1906         1.6E9
COI_2B    1906    9         10E-12
ROI_3B       11 1907         1.6E9
COI_3B    1907    9         10E-12
ROI_4B       10 1908         1.6E9
COI_4B    1908    9         10E-12
*
* MODELS USED
*
.MODEL SNCM  VSWITCH (RON=1 ROFF=400001 VON=18 VOFF=-60)
.MODEL SPCM  VSWITCH (RON=450000 ROFF=1 VON=50 VOFF=-13.5)
.MODEL SBASE VSWITCH (RON=27 ROFF=1400 VON=28 VOFF=-10)
.MODEL SMAINP VSWITCH (RON=250001 ROFF=12 VON=24.5 VOFF=0)
.MODEL SMAINN VSWITCH (RON=250001 ROFF=6 VON=24.5 VOFF=0)
.MODEL Sdemux VSWITCH (RON=1 ROFF=1E12 VON=2.0 VOFF=1.4)
.MODEL DClamp D(IS=1E-15 IBV=1E-13 CJO=1E-12)
.MODEL SLEAK VSWITCH (RON=750E9 ROFF=150E9 VON=-15 VOFF=15)
.PARAM GMIN=1E-14
.ENDS ADG409

.MODEL 4013B_5__CMOS_5V__1 d_chip ( behaviour= "
+;4013 Dual D Flip Flop @5V
+/inputs  D SD CD CP
+/outputs O ~O
+;clock input_number edge{+|-} number_of_flags sync_entries async_entries
+/clock CP + 1 4 4
+;SYNC
+; D  SD  CD  CP CF  NF
+  L   L   L  X  X   L
+  H   L   L  X  X   H
+  X   H   H  X  X   H
+  X   X   X  X  X   F0
+;ASYNC
+; D  SD  CD  CP CF  NF
+  X   H   L  X  X   H
+  X   H   H  X  X   H
+  X   L   H  X  X   L
+  X   L   L  X  X   F0
+/table 5
+; D  SD  CD  CP Flag Q1  ~Q1
+  X   H   H  X  X     F0   F0
+  X   H   L  X  X      F0  ~F0
+  X   L   H  X  X      F0  ~F0
+  X   L   L  X  X       F0  ~F0
+  X   X   X  X  X      F0  ~F0
+/delay 6
+;input  output  Rise time  Fall time
+  CP      O      190n       220n
+  CP     ~O      190n       220n
+  SD      O      150n        X
+  SD     ~O       X         200n
+  CD      O       X         200n
+  CD     ~O      120n        X
+/constraint 9
+;   Name       Event From  Event To   Min/Max  Time
+ 'PULSE WIDTH'  HL    CP    LH   CP     MIN     60n
+ 'PULSE WIDTH'  LH    SD    HL   SD     MIN     50n
+ 'PULSE WIDTH'  LH    CD    HL   CD     MIN     50n
+ 'SETUP'        HL    D     HL   CP     MIN     40n
+ 'SETUP'        LH    D     HL   CP     MIN     40n
+ 'RECOVERY'     HL    CP    LH   SD     MIN     15n
+ 'RECOVERY'     HL    CP    LH   CD     MIN     40n
+ 'HOLD'         HL    CP    HL    D     MIN     20n
+ 'HOLD'         HL    CP    LH    D     MIN     20n
+")

.SUBCKT CMOS_DRV__NON__1 1 2 3 4
* CMOS Driver Model  1 = D/A input, 2 = out 3= VCC 4 = VSS(GND)
*#L1
aDAC1in  [1]  [2] aDAC1
.MODEL aDAC1 dac_bridge (out_low= 0 out_high = 5.0 out_undef = 0)
*#L1

.ENDS

.SUBCKT CMOS_RCV__NON__1 1 2 3 4
* CMOS LOAD Model  1 = input, 2 = A/D out 3 = VCC 4 = VSS(GND)
*#L1
aADC1in [1] [2] ADC1
.MODEL ADC1 adc_bridge (in_low= 2.5 in_high = 2.5)
*#L1

.ENDS

.subckt XXFG1_420821240 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

.subckt XXFG5_420821240 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
.subckt XXFG4_420821240 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
.subckt XXFG3_420821240 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
.subckt XXFG2_420821240 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends
